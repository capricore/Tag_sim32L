# Keil uVision project Tag_sim32L.uvproj, settings and files
target Tag_sim32L (ARM-ADS)
  device: SiM3L144 Silicon Laboratories, Inc.
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x0-0xFFFF) CLOCK(20000000) CPUTYPE("Cortex-M3")
  output: Tag_sim32L
  c flags: Optim=1
  c define: NDEBUG
  c misc: --c99 --gnu
  c include: .;generated;D:\Silabs\32bit\si32-1.1.2\si32Hal\CPU;D:\Silabs\32bit\si32-1.1.2\si32Hal\SI32_Modules;D:\Silabs\32bit\si32-1.1.2\si32Hal\sim3l1xx;.\app;.\arch;.\as3933;.\option;.\rf2xx;.\system_param;.\exciter
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: D:\Silabs\32bit\si32-1.1.2\si32Hal\sim3l1xx\linker_sim3l1xx_arm.sct
  group SiM3xxxx
    D:/Silabs/32bit/si32-1.1.2/si32Hal/CPU/: retarget_arm.c
    D:/Silabs/32bit/si32-1.1.2/si32Hal/sim3l1xx/: startup_sim3l1xx_arm.s system_sim3l1xx.c
    D:/Silabs/32bit/si32-1.1.2/si32Hal/SI32_Modules/: SI32_EXTOSC_A_Type.c SI32_PLL_A_Type.c SI32_RTC_B_Type.c SI32_SARADC_A_Type.c SI32_CMP_A_Type.c SI32_IDAC_A_Type.c SI32_PVTOSC_A_Type.c SI32_I2C_A_Type.c SI32_SPI_B_Type.c SI32_USART_B_Type.c SI32_UART_B_Type.c SI32_FLASHCTRL_A_Type.c SI32_DCDC_A_Type.c SI32_VMON_B_Type.c SI32_VREF_B_Type.c SI32_LPTIMER_B_Type.c SI32_EPCA_A_Type.c SI32_EPCACH_A_Type.c SI32_TIMER_A_Type.c SI32_WDTIMER_A_Type.c SI32_AES_B_Type.c SI32_ECRC_A_Type.c SI32_ENCDEC_A_Type.c SI32_ACCTR_A_Type.c
  group SIM3L1XX
    D:/Silabs/32bit/si32-1.1.2/si32Hal/sim3l1xx/: SI32_PMU_A_Type.c SI32_LDO_A_Type.c SI32_LOCK_A_Type.c SI32_RSTSRC_A_Type.c
  group Tag_sim32L
    ./: main.c
  group app
    ./app/: configuration.c event_exciter.c event_receive_pkt.c event_wk_time.c flash_operation.c systick.c workstate.c
  group as3933
    ./as3933/: as3933.c as3933_hal.c as3933_spi.c as3933_tat.c
  group arch
    ./arch/: CLKCTRL.c CPU.c DCDC.c FLASHCTRL.c mcu.c Modes.c PB.c PMU.c rtc_alarm_relative.c RTC0.c timeout.c WDTIMER0.c
  group rf2xx
    ./rf2xx/: csma.c mac_state.c rf2xx_hal.c rf2xx_init.c rf2xx_mcu.c rf2xx_option.c rf2xx_protoc.c rf2xx_recv.c rf2xx_send.c rf2xx_spi.c rf2xx_tat.c rf2xx_version.c
  group option
    ./option/: crc.c
  group system_param
    ./system_param/: sysparam.c sysparam_option.c
